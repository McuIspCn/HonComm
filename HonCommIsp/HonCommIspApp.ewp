# IAR project HonCommIspApp.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HonCommIspApp.hex
  postbuild: "iarCopyHex2in1.bat" "..\objout\HonCommLoader\Debug\Exe\HonCommLoader.hex" "..\objout\HonCommIspApp\Debug\Exe\HonCommIspApp.hex" "..\objout\HonCommApp.hex"
  ILINK.IlinkOutputFile: HonCommIspApp.out
  ILINK.IlinkIcfFile: HonCommIspApp_Sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: HonCommAppmain.c HonCommIspAppPage0.c startup_SetSp.s
