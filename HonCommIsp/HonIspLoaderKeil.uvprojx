# Keil uVision project HonIspLoaderKeil.uvprojx, settings and files
target IspLoader (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HonIspLoaderKeil +hex
  AfterMake: .\KeilCopyHex2in1.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\HonIspLoader0Keil.sct
  group HonLoader
    ./: startup_keilSetSp.s HonCommLoadermain.c
