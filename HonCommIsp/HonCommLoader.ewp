# IAR project HonCommLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: HonCommLoader.hex
  postbuild: "iarCopyHex2in1.bat" "..\objout\HonCommLoader\Debug\Exe\HonCommLoader.hex" "..\objout\HonCommIspApp\Debug\Exe\HonCommIspApp.hex" "..\objout\HonCommApp.hex"
  ILINK.IlinkOutputFile: HonCommLoader.out
  ILINK.IlinkIcfFile: HonCommLoader_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: HonCommLoadermain.c startup_SetSp.s
