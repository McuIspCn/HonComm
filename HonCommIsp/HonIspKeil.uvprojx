# Keil uVision project HonIspKeil.uvprojx, settings and files
target IspApp (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HonIspAppKeil +hex
  AfterMake: .\KeilCopyHex2in1.bat
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\HonIspAppKeil.sct
  group HonIsp
    ./: startup_keilSetSp.s HonCommAppmain.c HonCommIspAppPage0.c
